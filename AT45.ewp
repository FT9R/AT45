# IAR project AT45.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107RC ST STM32F107RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: Config; Include; Souce; Libraries\SPL\inc; Libraries\SPL\src; Libraries\Delay; Libraries\SPI; Libraries\AT45
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Config
    Config/: startup_stm32f10x_cl.s stm32f10x.h stm32f10x_conf.h Sys_Init.c Sys_Init.h system_stm32f10x.c system_stm32f10x.h
  group Include
    Include/: Init.h main.h
  group Libraries/AT45
    Libraries/AT45/: AT45.c AT45.h
  group Libraries/Delay
    Libraries/Delay/: Delay.c Delay.h
  group Libraries/SPI
    Libraries/SPI/: SPI.c SPI.h
  group Libraries/SPL/inc
    Libraries/SPL/inc/: stm32f10x_rcc.h stm32f10x_spi.h
  group Libraries/SPL/src
    Libraries/SPL/src/: stm32f10x_rcc.c stm32f10x_spi.c
  group Source
    Source/: Init.c main.c
